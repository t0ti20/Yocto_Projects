#Change Source Files Location
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
#Select My Custom Configure Uboot Commands
SRC_URI = "file://boot.cmd.in"